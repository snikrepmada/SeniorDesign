# Keil uVision project camera2640.uvprojx, settings and files
target camera2640 Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: camera2640 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: camera2640 Configuration\camera2640 Configuration.sct
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c i2c.c gpio.c stm32f4xx_it.c dma.c dcmi.c spi.c usbd_cdc_if.c usart.c usbd_desc.c usb_device.c usbd_conf.c debug.c ov2640.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
